# Keil uVision project U_PSDR_VSL_CT6K_EMS.uvprojx, settings and files
target U_PSDR_VSL_CT6K_EMS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G0B1VETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: U_PSDR_VSL_CT6K_EMS +hex
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  AfterMake: BinEncoder_STM32G0_CT6K.exe $L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,CVTE_INV_VSL_6K_EMS = 1,STM32G0B1xx,USE_HAL_DRIVER,USER_VECT_TAB_ADDRESS
  c include: ..\..\..\Board;..\..\..\Core\Communication;..\..\..\Core\CustomerConfig;..\..\..\Core\Eeprom;..\..\..\Core\Head;..\..\..\Core\StartUp;..\..\..\Core\User;..\..\..\Core\User\BatteryModule;..\..\..\Device\Boost_Device;..\..\..\Device\INV_Device;..\..\..\Device\LLC_Device;..\..\..\Device\PFC_Device;..\..\..\Device\Public_Device;..\..\..\Device\Public_Device\Math;..\..\..\Driver\STM32G4xx_driver;..\..\..\Library\STM32G0xx_DFP\CMSIS\Device\ST\STM32G0xx\Include;..\..\..\Library\STM32G0xx_DFP\STM32G0xx_HAL_Driver\Inc;..\..\..\Library\STM32G0xx_DFP\STM32G0xx_HAL_Driver\Inc\Legacy;..\..\..\Service;..\..\..\Service\Parallel_Service;..\..\..\Service\SPS_Service;..\..\..\Library\STM32G0xx_DFP\CMSIS\Include;..\..\..\Library;..\..\..\Library\STM32G0xx_DFP\STM32G0xx_HAL_Driver\Inc;..\..\..\Library\STM32G0xx_DFP\CMSIS\Device\ST\STM32G0xx\Include;..\..\..\Device
  memory RVCT4: ROM 0x8003000 size 0x7d000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../Core/StartUp/: main.c MCU.c TimeTask.c PublicFunc.c GlobalVar.c
    ../../../Library/STM32G0xx_DFP/CMSIS/Device/ST/STM32G0xx/Source/Templates/arm/: startup_stm32g0b1xx.s
    ../../../Library/STM32G0xx_DFP/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
    ../../../Library/STM32G0xx_DFP/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_cortex.c
  group Board
    ../../../Board/: BOARD_U_CNTL_VSL6K_A_STM32G0B1VET6.h
  group Config
    ../../../Core/CustomerConfig/: Config_CVTE_VSL_6K.h Config.h
  group User
    ../../../Core/Communication/: COMMDeal_CVTE.c
  group Services
    ../../../Service/: Buzzer_Service.c LCD_Service.c Key_Service.c RTC_Service.c NTC_DRM_Service.c DisplayChineseTab.c Storage_Management_Service.c Energy_Management_Service.c Battery_Protect_Service.c Fault_Management_Service.c Indication_Management_Service.c Statistics_Management_Service.c
    ../../../Core/Communication/: Modbus.c Modbus_RTU_Slave.c Modbus_RTU_Master.c Modbus_ASCII_Master.c Modbus_Data_Deal.c Modbus_PCS_COMData.c Modbus_BMS_COMData.c Modbus_Meter_COMData.c Modbus_Bluetooth_COMData.c Modbus_WifiGprs_COMData.c Canbus_BMS_COMData.c Canbus_EmsParallel_COMData.c Modbus_CLOUD_COMData.c
  group Devices
    ../../../Device/Public_Device/: Buzzer_Device.c Key_Device.c LCD_KS0108_6800_Device.c Flash_Device.c BL5372_Device.c PCF8563_Device.c RTC_Device.c
    ../../../Device/: NTC_Device.c SR_VirtualDevice.c
  group Driver
    ../../../Driver/STM32G4xx_driver/: iwdg_driver.c gpio_driver.c adc_driver.c tim_driver.c dma_driver.c uart_driver.c Flash_Driver.c SPI_driver.c I2C_driver.c rtc_driver.c can_driver.c
  group Library
    ../../../Library/STM32G0xx_DFP/STM32G0xx_HAL_Driver/Inc/: stm32_assert_template.h stm32g0xx_ll_adc.h stm32g0xx_ll_bus.h stm32g0xx_ll_comp.h stm32g0xx_ll_cortex.h stm32g0xx_ll_crc.h stm32g0xx_ll_crs.h stm32g0xx_ll_dac.h stm32g0xx_ll_dma.h stm32g0xx_ll_dmamux.h stm32g0xx_ll_exti.h stm32g0xx_ll_gpio.h stm32g0xx_ll_i2c.h stm32g0xx_ll_iwdg.h stm32g0xx_ll_lptim.h stm32g0xx_ll_lpuart.h stm32g0xx_ll_pwr.h stm32g0xx_ll_rcc.h stm32g0xx_ll_rng.h stm32g0xx_ll_rtc.h stm32g0xx_ll_spi.h stm32g0xx_ll_system.h stm32g0xx_ll_tim.h stm32g0xx_ll_ucpd.h stm32g0xx_ll_usart.h stm32g0xx_ll_usb.h stm32g0xx_ll_utils.h stm32g0xx_ll_wwdg.h
    ../../../Library/STM32G0xx_DFP/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c stm32g0xx_hal.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c
